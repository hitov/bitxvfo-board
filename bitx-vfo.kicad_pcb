# Repository hitov/bitxvfo-board

File README.md:

# bitxvfo-board
Bitx VFO experimental board - initial commit

## KiCad design bitx-vfo.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6: C; C1
L1: INDUCTOR; R1
P1: BNC; SMA
P2: ED1112S; ed1112s
Q1, Q2: NPN; TO92PN
R1, R2, R3, R4, R6, R7, R8, R9, R10, R11, R12: R; R3-LARGE_PADS
R5: RVAR; RV2
U1: AD9850-MOD; ad9850-mod
U2: ARDUINO_NANO; arduino_mini
U3: LCD5110; lcd5110

Connections:
+3.3V: U2.2, U3.6 (VCC)
+5V: C3.2, L1.2, R10.1, U2.12
/DATA: R8.1, U2.28
/FU_UD: R7.1, U2.27
/RESET: R9.1, U2.1
/W_CLK: R6.1, U2.26
GND: C2.1, C3.1, C5.2, C6.2, P1.2 (Ext), P2.2, P2.4, Q2.1 (E), R1.2, R4.2, R11.2, U2.14, U2.19, U3.8 (GND)
unnamed: P2.5, U2.29
unnamed: C5.1, C6.1, R10.2, U1.1 (VCC), U1.20 (VCC)
unnamed: R12.2, U3.1 (RST)
unnamed: U2.22, U3.2 (CE)
unnamed: U2.23, U3.3 (DC)
unnamed: U2.24, U3.4 (DIN)
unnamed: U2.25, U3.5 (CLK)
unnamed: P2.1, U2.20
unnamed: P2.3, U2.21
unnamed: R9.2, U1.5 (RESET)
unnamed: R11.1, U3.7 (LIGHT)
unnamed: C1.1, P1.1 (In)
unnamed: C4.2, U1.9 (ZOUT1)
unnamed: R12.1, U2.30
unnamed: Q1.2 (B), Q2.3 (C), R3.2
unnamed: R8.2, U1.4 (DATA)
unnamed: R7.2, U1.3 (FU_UD)
unnamed: R6.2, U1.2 (W_CLK)
unnamed: Q2.2 (B), R2.2, R4.1, R5.1
unnamed: C2.2, L1.1, Q1.3 (C), R3.1
unnamed: C1.2, Q1.1 (E), R1.1, R2.1
unnamed: C4.1, R5.2

Board: 2 copper layers, 132.1 x 45.0 mm, 26 parts (0 on the bottom side), 29 nets.

## Commit log

2016-11-06 Add schematics and board files
